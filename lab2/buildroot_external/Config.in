## lab2/buildroot_external/package/dev_module/Config.in
```kconfig
config BR2_PACKAGE_DEV_MODULE
        bool "dev_module"
        help
		Dev module
```
